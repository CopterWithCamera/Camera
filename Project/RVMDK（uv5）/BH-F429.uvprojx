# Keil uVision project BH-F429.uvprojx, settings and files
target OV5640 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OV5640 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\FATFS;..\..\User\FATFS\drivers;..\..\User\NRF;..\..\User\CameraImageFix
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Output\OV5640.sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: include.h main.c stm32f4xx_it.c image_processing.c copter_datatrans.c copter_datatrans.h
    ../../User/camera/: bsp_ov5640.c ov5640_AF.c
    ../../User/sdram/: bsp_sdram.c
    ../../User/usart/: bsp_debug_usart.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/systick/: bsp_SysTick.c
    ../../User/key/: bsp_exti.c
    ../../User/NRF/: bsp_spi_nrf.c
    ../../User/CameraImageFix/: image_fix.c
  group DOC
    ../../: 必读说明.txt
    ../../Doc/: 内存分配更改文档.txt 摄像头故障排除文档.txt 摄像头分辨率修改文档.txt 整体修改文档.txt 整体设计思路.txt
  group FATFS
    ../../User/FATFS/drivers/: fatfs_sd_sdio.c
    ../../User/FATFS/: diskio.c ff.c rgbTObmp.c
    ../../User/FATFS/option/: cc936.c
